# IAR project LCP_Control.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO3
  ICCARM.CCDiagSuppress: Pe177
  ICCARM.CCIncludePath2: inc; src; bsp; $AMBIQ_DIR$\mcu\apollo3; $AMBIQ_DIR$\utils; $AMBIQ_DIR$\CMSIS\AmbiqMicro\Include; $AMBIQ_DIR$\CMSIS\ARM\Include; $AMBIQ_DIR$\devices
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: inc; src; bsp; $AMBIQ_DIR$\mcu\apollo3\; $AMBIQ_DIR$\utils; $AMBIQ_DIR$\CMSIS\AmbiqMicro\Include; $AMBIQ_DIR$\CMSIS\ARM\Include; $AMBIQ_DIR$\devices
  OBJCOPY.OOCOutputFile: LCP_Control.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: $AMBIQ_DIR$\mcu\apollo3\hal\iar\bin\libam_hal.a; $AMBIQ_DIR$\boards\apollo3_evb\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: fast_gpio.c
    ./: main.c
  group ambiq/devices
    $AMBIQ_DIR$/devices/: am_devices_led.c am_devices_led.h
  group ambiq/mcu/apollo3
    $AMBIQ_DIR$/mcu/apollo3/: am_mcu_apollo.h
  group ambiq/mcu/apollo3/hal
    $AMBIQ_DIR$/mcu/apollo3/hal/: am_hal_adc.c am_hal_adc.h am_hal_ble.c am_hal_ble.h am_hal_ble_patch.c am_hal_ble_patch.h am_hal_ble_patch_b0.c am_hal_ble_patch_b0.h am_hal_burst.c am_hal_burst.h am_hal_cachectrl.c am_hal_cachectrl.h am_hal_clkgen.c am_hal_clkgen.h am_hal_cmdq.c am_hal_cmdq.h am_hal_ctimer.c am_hal_ctimer.h am_hal_debug.c am_hal_debug.h am_hal_flash.c am_hal_flash.h am_hal_global.c am_hal_global.h am_hal_gpio.c am_hal_gpio.h am_hal_interrupt.c am_hal_interrupt.h am_hal_iom.c am_hal_iom.h am_hal_ios.c am_hal_ios.h am_hal_itm.c am_hal_itm.h am_hal_mcuctrl.c am_hal_mcuctrl.h am_hal_mspi.c am_hal_mspi.h am_hal_pdm.c am_hal_pdm.h am_hal_pin.h am_hal_pwrctrl.c am_hal_pwrctrl.h am_hal_pwrctrl_internal.h am_hal_queue.c am_hal_queue.h am_hal_reset.c am_hal_reset.h am_hal_rtc.c am_hal_rtc.h am_hal_scard.c am_hal_scard.h am_hal_secure_ota.c am_hal_secure_ota.h am_hal_security.c am_hal_security.h am_hal_status.h am_hal_stimer.c am_hal_stimer.h am_hal_sysctrl.c am_hal_sysctrl.h am_hal_systick.c am_hal_systick.h am_hal_tpiu.c am_hal_tpiu.h am_hal_uart.c am_hal_uart.h am_hal_wdt.c am_hal_wdt.h
  group ambiq/mcu/apollo3/regs
    $AMBIQ_DIR$/mcu/apollo3/regs/: am_reg.h am_reg_base_addresses.h am_reg_iomstr_cmd.h am_reg_jedec.h am_reg_m4.h am_reg_macros.h am_reg_macros_asm.h
  group ambiq/utils
    $AMBIQ_DIR$/utils/: am_util.h am_util_ble.c am_util_ble.h am_util_debug.c am_util_debug.h am_util_delay.c am_util_delay.h am_util_faultisr.c am_util_id.c am_util_id.h am_util_regdump.c am_util_regdump.h am_util_stdio.c am_util_stdio.h am_util_string.c am_util_string.h am_util_time.c am_util_time.h
  group bsp
    bsp/: am_bsp.c am_bsp.h am_bsp_pins.c am_bsp_pins.h
  group src
    src/: LED.c LED.h
