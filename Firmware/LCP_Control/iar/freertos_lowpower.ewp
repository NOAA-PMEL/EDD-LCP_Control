# IAR project freertos_lowpower.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO3; AM_PACKAGE_BGA; AM_FREERTOS; AM_DEBUG_PRINTF; AM_UTIL_FAULTISR_PRINT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: $AMBIQ_SDK$\third_party\FreeRTOSv10.1.1\Source\include; $AMBIQ_SDK$\CMSIS\AmbiqMicro\Include; $AMBIQ_SDK$\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; $AMBIQ_SDK$; $AMBIQ_SDK$\devices; $AMBIQ_SDK$\utils; ..\src; ..\src\RTOS; ..\src\artemis; ..\src\bsp; $AMBIQ_SDK$\mcu\apollo3; $AMBIQ_SDK$\CMSIS\ARM\Include; $PROJ_DIR\src\RTOS; $AMBIQ_SDK$\mcu\apollo3\hal
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $AMBIQ_SDK$\third_party\FreeRTOSv10.1.1\Source\include; $AMBIQ_SDK$\CMSIS\AmbiqMicro\Include; $AMBIQ_SDK$\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; $AMBIQ_SDK$; $AMBIQ_SDK$\devices; $AMBIQ_SDK$\utils; ..\src; ..\src\bsp; ..\src\RTOS; $AMBIQ_SDK$\mcu\apollo3; $AMBIQ_SDK$\CMSIS\ARM\Include
  OBJCOPY.OOCOutputFile: freertos_lowpower.bin
  ILINK.IlinkOutputFile: freertos_lowpower.out
  ILINK.IlinkIcfFile: freertos_lowpower.icf
  ILINK.IlinkAdditionalLibs: C:\Tools\Ambiq\AmbiqSuite-R2.5.1\mcu\apollo3\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO3; AM_PACKAGE_BGA; AM_FREERTOS; AM_DEBUG_PRINTF; AM_UTIL_FAULTISR_PRINT
  ICCARM.CCIncludePath2: ..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\include; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; ..\..\..\..\..; ..\..\..\..\..\devices; ..\..\..\..\..\utils; ..\src; ..\..\..\..\..\mcu\apollo3; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\bsp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a
  group (top)
    ../src/: freertos_lowpower.c led_task.c main.h
    ../: main.c
    ./: startup_iar.c
  group ambiq
    $AMBIQ_SDK$/devices/: am_devices_button.c am_devices_led.c
    $AMBIQ_SDK$/utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group ambiq/HAL
    $AMBIQ_SDK$/mcu/apollo3/hal/: am_hal_adc.c am_hal_adc.h am_hal_ble.c am_hal_ble.h am_hal_ble_patch.c am_hal_ble_patch.h am_hal_ble_patch_b0.c am_hal_ble_patch_b0.h am_hal_burst.c am_hal_burst.h am_hal_cachectrl.c am_hal_cachectrl.h am_hal_clkgen.c am_hal_clkgen.h am_hal_cmdq.c am_hal_cmdq.h am_hal_ctimer.c am_hal_ctimer.h am_hal_debug.c am_hal_debug.h am_hal_flash.c am_hal_flash.h am_hal_global.c am_hal_global.h am_hal_gpio.c am_hal_gpio.h am_hal_interrupt.c am_hal_interrupt.h am_hal_iom.c am_hal_iom.h am_hal_ios.c am_hal_ios.h am_hal_itm.c am_hal_itm.h am_hal_mcuctrl.c am_hal_mcuctrl.h am_hal_mspi.c am_hal_mspi.h am_hal_pdm.c am_hal_pdm.h am_hal_pin.h am_hal_pwrctrl.c am_hal_pwrctrl.h am_hal_pwrctrl_internal.h am_hal_queue.c am_hal_queue.h am_hal_reset.c am_hal_reset.h am_hal_rtc.c am_hal_rtc.h am_hal_scard.c am_hal_scard.h am_hal_secure_ota.c am_hal_secure_ota.h am_hal_security.c am_hal_security.h am_hal_status.h am_hal_stimer.c am_hal_stimer.h am_hal_sysctrl.c am_hal_sysctrl.h am_hal_systick.c am_hal_systick.h am_hal_tpiu.c am_hal_tpiu.h am_hal_uart.c am_hal_uart.h am_hal_wdt.c am_hal_wdt.h
  group artemis
    ../src/artemis/: artemis_debug.c artemis_debug.h artemis_i2c.c artemis_i2c.h artemis_iom.c artemis_iom.h artemis_max14830.c artemis_max14830.h artemis_mcu.c artemis_mcu.h artemis_pa9ld.c artemis_pa9ld.h artemis_spi.c artemis_spi.h artemis_stream.c artemis_stream.h artemis_time.c artemis_time.h artemis_ublox_i2c.c artemis_ublox_i2c.h
  group BSP
    ../src/bsp/: am_bsp.c am_bsp.h am_bsp_pins.c am_bsp_pins.h bsp_uart.c bsp_uart.h
  group RTOS
    $AMBIQ_SDK$/third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../src/RTOS/: FreeRTOSConfig.h rtos.c rtos.h
    $AMBIQ_SDK$/third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
    $AMBIQ_SDK$/third_party/FreeRTOSv10.1.1/Source/portable/IAR/AMapollo2/: port.c portasm.s
  group src
    ../src/: buffer_c.c buffer_c.h LED.c LED.h MAX14830.c MAX14830.h S9_temp.c S9_temp.h
